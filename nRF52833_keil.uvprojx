# Keil uVision project nRF52833_keil.uvprojx, settings and files
target nRF52833 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00800000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nRF52833_keil +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c misc: --reduce_paths
  c include: .\inc;.\Application\inc
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x800000 size 0x20000
  link misc: --diag_suppress 6330
  group Application
    ./Application/src/: main.c global.c
    ./inc/: sdk_config.h
    ./Application/inc/: global.h
  group nRF_Drivers
    ./src/: nrf_drv_uart.c nrfx_atomic.c nrfx_gpiote.c nrfx_prs.c nrfx_uart.c nrfx_uarte.c nrf_drv_spi.c nrfx_spi.c nrfx_spim.c
  group nRF_Libraries
    ./src/: app_error.c app_error_handler_keil.c app_error_weak.c app_fifo.c app_uart_fifo.c app_util_platform.c nrf_assert.c nrf_atomic.c nrf_balloc.c nrf_fprintf.c nrf_fprintf_format.c nrf_memobj.c nrf_ringbuf.c nrf_strerror.c retarget.c
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
